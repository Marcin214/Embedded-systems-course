# Keil uVision project project.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: LPC2129/01 NXP
  cpu: IRAM(0x40000000-0x40003FFF) IROM(0-0x3FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: project +hex
  c flags: Optim=1 uC99=1
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x40000000 size 0x4000
  group Source Group 1
    ./: Startup.s main.c keyboard.c led.c delay.c timer.c timer_interrupts.c servo.c uart.c mystring.c watch.c command_decoder.c
